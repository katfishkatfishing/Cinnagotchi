## Firmware/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_FREETOS_HZ=1000
CONFIG_ESP_DEFAULT_CPU_FRE_MHZ_240=y
CONFIG_SPIRAM_SUPPORT=y
CONFIG_SPIRAM_MOCE_OCT=y
```
